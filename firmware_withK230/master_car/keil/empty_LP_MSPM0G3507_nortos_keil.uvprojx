# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target master_car_withK230 (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: master_car_withK230 +hex
  BeforeMake: cmd.exe /C ""C:\ti\sysconfig_1.21.1\sysconfig_cli.bat" -o "$P.." -s "D:\ti2\mspm0_sdk_2_02_00_05\.metadata\product.json" --compiler keil "$P..\empty.syscfg""
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..,..\App,..\Control,..\Hardware,..\System,..\User,D:\ti2\mspm0_sdk_2_02_00_05\source\third_party\CMSIS\Core\Include,D:\ti2\mspm0_sdk_2_02_00_05\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: D:\ti2\mspm0_sdk_2_02_00_05\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group User
    ../User/: main.c
    ./: startup_mspm0g350x_uvision.s
    ../: empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
  group App
    ../App/: app_car_base.c app_car_state.c app_control.c app_line.c app_h26.c app_h26_led.c app_h26_task2.c app_board_test.c app_radio.c app_vision_link.c app_vision_track.c
  group Control
    ../Control/: pid.c
  group Hardware
    ../Hardware/: PWM.c Motor.c Encoder.c Grayscale.c Key.c Serial.c DebugSerial.c OLED.c BeepLed.c Servo.c StepperEncoder.c NRF24L01.c JY61P.c JY61P_Serial.c Board_Config.h JY61P.h JY61P_Serial.h
  group System
    ../System/: Timer.c
